# Keil uVision project SterilizeRobot.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SterilizeRobot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: .\FREERTOS\include;.\FREERTOS\portable\RVDS\ARM_CM4F;.\CORE;.\DRIVER\inc;.\FWLIB\inc;.\USER\inc;.\USER_LIB\inc;.\lwip_v1.3.2\doc;.\lwip_v1.3.2\port\STM32F4x7\arch;.\lwip_v1.3.2\port\STM32F4x7\Standalone;.\lwip_v1.3.2\src\api;.\lwip_v1.3.2\src\core\ipv4;.\lwip_v1.3.2\src\core\snmp;.\lwip_v1.3.2\src\include\ipv4\lwip;.\lwip_v1.3.2\src\include\lwip;.\lwip_v1.3.2\src\include\netif;.\lwip_v1.3.2\src\netif\ppp;.\STM32F4x7_ETH_Driver\inc;.\STM32F4x7_ETH_Driver\DP83848;.\STM32F4x7_ETH_Driver\LWIP_APP;.\ws2812b
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FWIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group DRIVER
    ./DRIVER/src/: Adc.c IIc.c Timer.c Usart.c
  group USER_LIB
    ./USER_LIB/src/: Device.c delay.c User_Conf.c sysz.c
  group USER
    ./USER/inc/: stm32f4xx_it.h
    ./FREERTOS/include/: FreeRTOSConfig.h
    ./USER/src/: stm32f4xx_it.c mian.c UserTask.c system_stm32f4xx.c ks136.c Usart1.c Power.c Data.c Rfid.c voice.c motor.c TemHum.c SystemCtrl.c
  group FreeROTS_Core
    ./FREERTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeROTS_PORTABLE
    ./FREERTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FREERTOS/portable/MemMang/: heap_4.c
  group LWIP
    ./lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./lwip_v1.3.2/src/netif/: etharp.c loopif.c
    ./lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group ws2812
    ./ws2812b/: ws2812b.c
